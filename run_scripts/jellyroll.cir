* C:\Users\tom\code\pybamm_pnm\run_scripts\jellyroll.cir
Rbn180 0 N002 0.0001
Rbn182 N002 N004 0.0001
Rbn184 N004 N006 0.0001
Rbn186 N006 N008 0.0001
Rbn188 N008 N010 0.0001
Rbn190 N010 N012 0.0001
Rbn192 N012 N014 0.0001
Rbn194 N014 N016 0.0001
Rbn196 N016 N018 0.0001
Rbn198 N018 N020 0.0001
Rbn200 N020 N022 0.0001
Rbn202 N022 N024 0.0001
Rbn204 N024 N026 0.0001
Rbn206 N026 N028 0.0001
Rbn208 N028 N030 0.0001
Rbn210 N030 N032 0.0001
Rbn212 N032 N034 0.0001
Rbn214 N034 N036 0.0001
Rbn216 N036 N038 0.0001
Rbn218 N038 N040 0.0001
Rbn220 N040 N042 0.0001
Rbn222 N042 N044 0.0001
Rbn224 N044 N046 0.0001
Rbn226 N046 N048 0.0001
Rbn228 N048 N050 0.0001
Rbn230 N050 N052 0.0001
Rbn232 N052 N054 0.0001
Rbn234 N054 N056 0.0001
Rbn236 N056 N058 0.0001
Rbn238 N058 N060 0.0001
Rbn240 N060 N062 0.0001
Rbn242 N062 N064 0.0001
Rbn244 N064 N066 0.0001
Rbn246 N066 N068 0.0001
Rbn248 N068 N070 0.0001
Rbn250 N070 N072 0.0001
Rbn252 N072 N074 0.0001
Rbn254 N074 N076 0.0001
Rbn256 N076 N078 0.0001
Rbn258 N078 N080 0.0001
Rbn260 N080 N082 0.0001
Rbn262 N082 N084 0.0001
Rbn264 N084 N086 0.0001
Rbn266 N086 N088 0.0001
Rbn268 N088 N090 0.0001
Rbn270 N090 N092 0.0001
Rbn272 N092 N094 0.0001
Rbn274 N094 N096 0.0001
Rbn276 N096 N098 0.0001
Rbn278 N098 N100 0.0001
Rbn280 N100 N102 0.0001
Rbn282 N102 N104 0.0001
Rbn284 N104 N106 0.0001
Rbn286 N106 N108 0.0001
Rbn288 N108 N110 0.0001
Rbn290 N110 N112 0.0001
Rbn292 N112 N114 0.0001
Rbn294 N114 N116 0.0001
Rbn296 N116 N118 0.0001
Rbn298 N118 N120 0.0001
Rbn300 N120 N122 0.0001
Rbn302 N122 N124 0.0001
Rbn304 N124 N126 0.0001
Rbn306 N126 N128 0.0001
Rbn308 N128 N130 0.0001
Rbn310 N130 N132 0.0001
Rbn312 N132 N134 0.0001
Rbn314 N134 N136 0.0001
Rbn316 N136 N138 0.0001
Rbn318 N138 N140 0.0001
Rbn320 N140 N142 0.0001
Rbn322 N142 N144 0.0001
Rbn324 N144 N146 0.0001
Rbn326 N146 N148 0.0001
Rbn328 N148 N150 0.0001
Rbn330 N150 N152 0.0001
Rbn332 N152 N154 0.0001
Rbn334 N154 N156 0.0001
Rbn336 N156 N158 0.0001
Rbn338 N158 N160 0.0001
Rbn340 N160 N162 0.0001
Rbn342 N162 N164 0.0001
Rbn344 N164 N166 0.0001
Rbn346 N166 N168 0.0001
Rbn348 N168 N170 0.0001
Rbn350 N170 N172 0.0001
Rbn352 N172 N174 0.0001
Rbn354 N174 N176 0.0001
Rbn356 N176 N178 0.0001
Rbn358 N178 N180 0.0001
Rbn360 N180 N182 0.0001
Rbn362 N182 N184 0.0001
Rbn364 N184 N186 0.0001
Rbn366 N186 N188 0.0001
Rbn368 N188 N190 0.0001
Rbn370 N190 N192 0.0001
Rbn372 N192 N194 0.0001
Rbn374 N194 N196 0.0001
Rbn376 N196 N198 0.0001
Rbn378 N198 N200 0.0001
Rbn380 N200 N202 0.0001
Rbn382 N202 N204 0.0001
Rbn384 N204 N206 0.0001
Rbn386 N206 N208 0.0001
Rbn388 N208 N210 0.0001
Rbn390 N210 N212 0.0001
Rbn392 N212 N214 0.0001
Rbn394 N214 N216 0.0001
Rbn396 N216 N218 0.0001
Rbn398 N218 N220 0.0001
Rbn400 N220 N222 0.0001
Rbn402 N222 N224 0.0001
Rbn404 N224 N226 0.0001
Rbn406 N226 N228 0.0001
Rbn408 N228 N230 0.0001
Rbn410 N230 N232 0.0001
Rbn412 N232 N234 0.0001
Rbn414 N234 N236 0.0001
Rbn416 N236 N238 0.0001
Rbn418 N238 N240 0.0001
Rbn420 N240 N242 0.0001
Rbn422 N242 N244 0.0001
Rbn424 N244 N246 0.0001
Rbn426 N246 N248 0.0001
Rbn428 N248 N250 0.0001
Rbn430 N250 N252 0.0001
Rbn432 N252 N254 0.0001
Rbn434 N254 N256 0.0001
Rbn436 N256 N258 0.0001
Rbn438 N258 N260 0.0001
Rbn440 N260 N262 0.0001
Rbn442 N262 N264 0.0001
Rbn444 N264 N266 0.0001
Rbn446 N266 N268 0.0001
Rbn448 N268 N270 0.0001
Rbn450 N270 N272 0.0001
Rbn452 N272 N274 0.0001
Rbn454 N274 N276 0.0001
Rbn456 N276 N278 0.0001
Rbn458 N278 N280 0.0001
Rbn460 N280 N282 0.0001
Rbn462 N282 N284 0.0001
Rbn464 N284 N286 0.0001
Rbn466 N286 N288 0.0001
Rbn468 N288 N290 0.0001
Rbn470 N290 N292 0.0001
Rbn472 N292 N294 0.0001
Rbn474 N294 N296 0.0001
Rbn476 N296 N298 0.0001
Rbn478 N298 N300 0.0001
Rbn480 N300 N302 0.0001
Rbn482 N302 N304 0.0001
Rbn484 N304 N306 0.0001
Rbn486 N306 N308 0.0001
Rbn488 N308 N310 0.0001
Rbn490 N310 N312 0.0001
Rbn492 N312 N314 0.0001
Rbn494 N314 N316 0.0001
Rbn496 N316 N318 0.0001
Rbn498 N318 N320 0.0001
Rbn500 N320 N322 0.0001
Rbn502 N322 N324 0.0001
Rbn504 N324 N326 0.0001
Rbn506 N326 N328 0.0001
Rbn508 N328 N330 0.0001
Rbn510 N330 N332 0.0001
Rbn512 N332 N334 0.0001
Rbn514 N334 N336 0.0001
Rbn516 N336 N338 0.0001
Rbn518 N338 N340 0.0001
Rbn520 N340 N342 0.0001
Rbn522 N342 N344 0.0001
Rbn524 N344 N346 0.0001
Rbn526 N346 N348 0.0001
Rbn528 N348 N350 0.0001
Rbn530 N350 N352 0.0001
Rbn532 N352 N354 0.0001
Rbn534 N354 N356 0.0001
Rbn536 N356 N358 0.0001
Rbp181 N001 N003 0.0001
Rbp183 N003 N005 0.0001
Rbp185 N005 N007 0.0001
Rbp187 N007 N009 0.0001
Rbp189 N009 N011 0.0001
Rbp191 N011 N013 0.0001
Rbp193 N013 N015 0.0001
Rbp195 N015 N017 0.0001
Rbp197 N017 N019 0.0001
Rbp199 N019 N021 0.0001
Rbp201 N021 N023 0.0001
Rbp203 N023 N025 0.0001
Rbp205 N025 N027 0.0001
Rbp207 N027 N029 0.0001
Rbp209 N029 N031 0.0001
Rbp211 N031 N033 0.0001
Rbp213 N033 N035 0.0001
Rbp215 N035 N037 0.0001
Rbp217 N037 N039 0.0001
Rbp219 N039 N041 0.0001
Rbp221 N041 N043 0.0001
Rbp223 N043 N045 0.0001
Rbp225 N045 N047 0.0001
Rbp227 N047 N049 0.0001
Rbp229 N049 N051 0.0001
Rbp231 N051 N053 0.0001
Rbp233 N053 N055 0.0001
Rbp235 N055 N057 0.0001
Rbp237 N057 N059 0.0001
Rbp239 N059 N061 0.0001
Rbp241 N061 N063 0.0001
Rbp243 N063 N065 0.0001
Rbp245 N065 N067 0.0001
Rbp247 N067 N069 0.0001
Rbp249 N069 N071 0.0001
Rbp251 N071 N073 0.0001
Rbp253 N073 N075 0.0001
Rbp255 N075 N077 0.0001
Rbp257 N077 N079 0.0001
Rbp259 N079 N081 0.0001
Rbp261 N081 N083 0.0001
Rbp263 N083 N085 0.0001
Rbp265 N085 N087 0.0001
Rbp267 N087 N089 0.0001
Rbp269 N089 N091 0.0001
Rbp271 N091 N093 0.0001
Rbp273 N093 N095 0.0001
Rbp275 N095 N097 0.0001
Rbp277 N097 N099 0.0001
Rbp279 N099 N101 0.0001
Rbp281 N101 N103 0.0001
Rbp283 N103 N105 0.0001
Rbp285 N105 N107 0.0001
Rbp287 N107 N109 0.0001
Rbp289 N109 N111 0.0001
Rbp291 N111 N113 0.0001
Rbp293 N113 N115 0.0001
Rbp295 N115 N117 0.0001
Rbp297 N117 N119 0.0001
Rbp299 N119 N121 0.0001
Rbp301 N121 N123 0.0001
Rbp303 N123 N125 0.0001
Rbp305 N125 N127 0.0001
Rbp307 N127 N129 0.0001
Rbp309 N129 N131 0.0001
Rbp311 N131 N133 0.0001
Rbp313 N133 N135 0.0001
Rbp315 N135 N137 0.0001
Rbp317 N137 N139 0.0001
Rbp319 N139 N141 0.0001
Rbp321 N141 N143 0.0001
Rbp323 N143 N145 0.0001
Rbp325 N145 N147 0.0001
Rbp327 N147 N149 0.0001
Rbp329 N149 N151 0.0001
Rbp331 N151 N153 0.0001
Rbp333 N153 N155 0.0001
Rbp335 N155 N157 0.0001
Rbp337 N157 N159 0.0001
Rbp339 N159 N161 0.0001
Rbp341 N161 N163 0.0001
Rbp343 N163 N165 0.0001
Rbp345 N165 N167 0.0001
Rbp347 N167 N169 0.0001
Rbp349 N169 N171 0.0001
Rbp351 N171 N173 0.0001
Rbp353 N173 N175 0.0001
Rbp355 N175 N177 0.0001
Rbp357 N177 N179 0.0001
Rbp359 N179 N181 0.0001
Rbp361 N181 N183 0.0001
Rbp363 N183 N185 0.0001
Rbp365 N185 N187 0.0001
Rbp367 N187 N189 0.0001
Rbp369 N189 N191 0.0001
Rbp371 N191 N193 0.0001
Rbp373 N193 N195 0.0001
Rbp375 N195 N197 0.0001
Rbp377 N197 N199 0.0001
Rbp379 N199 N201 0.0001
Rbp381 N201 N203 0.0001
Rbp383 N203 N205 0.0001
Rbp385 N205 N207 0.0001
Rbp387 N207 N209 0.0001
Rbp389 N209 N211 0.0001
Rbp391 N211 N213 0.0001
Rbp393 N213 N215 0.0001
Rbp395 N215 N217 0.0001
Rbp397 N217 N219 0.0001
Rbp399 N219 N221 0.0001
Rbp401 N221 N223 0.0001
Rbp403 N223 N225 0.0001
Rbp405 N225 N227 0.0001
Rbp407 N227 N229 0.0001
Rbp409 N229 N231 0.0001
Rbp411 N231 N233 0.0001
Rbp413 N233 N235 0.0001
Rbp415 N235 N237 0.0001
Rbp417 N237 N239 0.0001
Rbp419 N239 N241 0.0001
Rbp421 N241 N243 0.0001
Rbp423 N243 N245 0.0001
Rbp425 N245 N247 0.0001
Rbp427 N247 N249 0.0001
Rbp429 N249 N251 0.0001
Rbp431 N251 N253 0.0001
Rbp433 N253 N255 0.0001
Rbp435 N255 N257 0.0001
Rbp437 N257 N259 0.0001
Rbp439 N259 N261 0.0001
Rbp441 N261 N263 0.0001
Rbp443 N263 N265 0.0001
Rbp445 N265 N267 0.0001
Rbp447 N267 N269 0.0001
Rbp449 N269 N271 0.0001
Rbp451 N271 N273 0.0001
Rbp453 N273 N275 0.0001
Rbp455 N275 N277 0.0001
Rbp457 N277 N279 0.0001
Rbp459 N279 N281 0.0001
Rbp461 N281 N283 0.0001
Rbp463 N283 N285 0.0001
Rbp465 N285 N287 0.0001
Rbp467 N287 N289 0.0001
Rbp469 N289 N291 0.0001
Rbp471 N291 N293 0.0001
Rbp473 N293 N295 0.0001
Rbp475 N295 N297 0.0001
Rbp477 N297 N299 0.0001
Rbp479 N299 N301 0.0001
Rbp481 N301 N303 0.0001
Rbp483 N303 N305 0.0001
Rbp485 N305 N307 0.0001
Rbp487 N307 N309 0.0001
Rbp489 N309 N311 0.0001
Rbp491 N311 N313 0.0001
Rbp493 N313 N315 0.0001
Rbp495 N315 N317 0.0001
Rbp497 N317 N319 0.0001
Rbp499 N319 N321 0.0001
Rbp501 N321 N323 0.0001
Rbp503 N323 N325 0.0001
Rbp505 N325 N327 0.0001
Rbp507 N327 N329 0.0001
Rbp509 N329 N331 0.0001
Rbp511 N331 N333 0.0001
Rbp513 N333 N335 0.0001
Rbp515 N335 N337 0.0001
Rbp517 N337 N339 0.0001
Rbp519 N339 N341 0.0001
Rbp521 N341 N343 0.0001
Rbp523 N343 N345 0.0001
Rbp525 N345 N347 0.0001
Rbp527 N347 N349 0.0001
Rbp529 N349 N351 0.0001
Rbp531 N351 N353 0.0001
Rbp533 N353 N355 0.0001
Rbp535 N355 N357 0.0001
Rbp537 N357 N359 0.0001
Rs0 N001 N360 1e-05
V0 N360 N361 3.6
Ri0 N361 0 60.0
Rs1 N003 N362 1e-05
V1 N362 N363 3.6
Ri1 N363 N002 60.0
Rs2 N005 N364 1e-05
V2 N364 N365 3.6
Ri2 N365 N004 60.0
Rs3 N007 N366 1e-05
V3 N366 N367 3.6
Ri3 N367 N006 60.0
Rs4 N009 N368 1e-05
V4 N368 N369 3.6
Ri4 N369 N008 60.0
Rs5 N011 N370 1e-05
V5 N370 N371 3.6
Ri5 N371 N010 60.0
Rs6 N013 N372 1e-05
V6 N372 N373 3.6
Ri6 N373 N012 60.0
Rs7 N015 N374 1e-05
V7 N374 N375 3.6
Ri7 N375 N014 60.0
Rs8 N017 N376 1e-05
V8 N376 N377 3.6
Ri8 N377 N016 60.0
Rs9 N019 N378 1e-05
V9 N378 N379 3.6
Ri9 N379 N018 60.0
Rs10 N021 N380 1e-05
V10 N380 N381 3.6
Ri10 N381 N020 60.0
Rs11 N023 N382 1e-05
V11 N382 N383 3.6
Ri11 N383 N022 60.0
Rs12 N025 N384 1e-05
V12 N384 N385 3.6
Ri12 N385 N024 60.0
Rs13 N027 N386 1e-05
V13 N386 N387 3.6
Ri13 N387 N026 60.0
Rs14 N029 N388 1e-05
V14 N388 N389 3.6
Ri14 N389 N028 60.0
Rs15 N031 N390 1e-05
V15 N390 N391 3.6
Ri15 N391 N030 60.0
Rs16 N033 N392 1e-05
V16 N392 N393 3.6
Ri16 N393 N032 60.0
Rs17 N035 N394 1e-05
V17 N394 N395 3.6
Ri17 N395 N034 60.0
Rs18 N037 N396 1e-05
V18 N396 N397 3.6
Ri18 N397 N036 60.0
Rs19 N039 N398 1e-05
V19 N398 N399 3.6
Ri19 N399 N038 60.0
Rs20 N041 N400 1e-05
V20 N400 N401 3.6
Ri20 N401 N040 60.0
Rs21 N043 N402 1e-05
V21 N402 N403 3.6
Ri21 N403 N042 60.0
Rs22 N045 N404 1e-05
V22 N404 N405 3.6
Ri22 N405 N044 60.0
Rs23 N047 N406 1e-05
V23 N406 N407 3.6
Ri23 N407 N046 60.0
Rs24 N049 N408 1e-05
V24 N408 N409 3.6
Ri24 N409 N048 60.0
Rs25 N051 N410 1e-05
V25 N410 N411 3.6
Ri25 N411 N050 60.0
Rs26 N053 N412 1e-05
V26 N412 N413 3.6
Ri26 N413 N052 60.0
Rs27 N055 N414 1e-05
V27 N414 N415 3.6
Ri27 N415 N054 60.0
Rs28 N057 N416 1e-05
V28 N416 N417 3.6
Ri28 N417 N056 60.0
Rs29 N059 N418 1e-05
V29 N418 N419 3.6
Ri29 N419 N058 60.0
Rs30 N061 N420 1e-05
V30 N420 N421 3.6
Ri30 N421 N060 60.0
Rs31 N063 N422 1e-05
V31 N422 N423 3.6
Ri31 N423 N062 60.0
Rs32 N065 N424 1e-05
V32 N424 N425 3.6
Ri32 N425 N064 60.0
Rs33 N067 N426 1e-05
V33 N426 N427 3.6
Ri33 N427 N066 60.0
Rs34 N069 N428 1e-05
V34 N428 N429 3.6
Ri34 N429 N068 60.0
Rs35 N071 N430 1e-05
V35 N430 N431 3.6
Ri35 N431 N070 60.0
Rs36 N073 N432 1e-05
V36 N432 N433 3.6
Ri36 N433 N072 60.0
Rs37 N075 N434 1e-05
V37 N434 N435 3.6
Ri37 N435 N074 60.0
Rs38 N077 N436 1e-05
V38 N436 N437 3.6
Ri38 N437 N076 60.0
Rs39 N079 N438 1e-05
V39 N438 N439 3.6
Ri39 N439 N078 60.0
Rs40 N081 N440 1e-05
V40 N440 N441 3.6
Ri40 N441 N080 60.0
Rs41 N083 N442 1e-05
V41 N442 N443 3.6
Ri41 N443 N082 60.0
Rs42 N085 N444 1e-05
V42 N444 N445 3.6
Ri42 N445 N084 60.0
Rs43 N087 N446 1e-05
V43 N446 N447 3.6
Ri43 N447 N086 60.0
Rs44 N089 N448 1e-05
V44 N448 N449 3.6
Ri44 N449 N088 60.0
Rs45 N091 N450 1e-05
V45 N450 N451 3.6
Ri45 N451 N090 60.0
Rs46 N093 N452 1e-05
V46 N452 N453 3.6
Ri46 N453 N092 60.0
Rs47 N095 N454 1e-05
V47 N454 N455 3.6
Ri47 N455 N094 60.0
Rs48 N097 N456 1e-05
V48 N456 N457 3.6
Ri48 N457 N096 60.0
Rs49 N099 N458 1e-05
V49 N458 N459 3.6
Ri49 N459 N098 60.0
Rs50 N101 N460 1e-05
V50 N460 N461 3.6
Ri50 N461 N100 60.0
Rs51 N103 N462 1e-05
V51 N462 N463 3.6
Ri51 N463 N102 60.0
Rs52 N105 N464 1e-05
V52 N464 N465 3.6
Ri52 N465 N104 60.0
Rs53 N107 N466 1e-05
V53 N466 N467 3.6
Ri53 N467 N106 60.0
Rs54 N109 N468 1e-05
V54 N468 N469 3.6
Ri54 N469 N108 60.0
Rs55 N111 N470 1e-05
V55 N470 N471 3.6
Ri55 N471 N110 60.0
Rs56 N113 N472 1e-05
V56 N472 N473 3.6
Ri56 N473 N112 60.0
Rs57 N115 N474 1e-05
V57 N474 N475 3.6
Ri57 N475 N114 60.0
Rs58 N117 N476 1e-05
V58 N476 N477 3.6
Ri58 N477 N116 60.0
Rs59 N119 N478 1e-05
V59 N478 N479 3.6
Ri59 N479 N118 60.0
Rs60 N121 N480 1e-05
V60 N480 N481 3.6
Ri60 N481 N120 60.0
Rs61 N123 N482 1e-05
V61 N482 N483 3.6
Ri61 N483 N122 60.0
Rs62 N125 N484 1e-05
V62 N484 N485 3.6
Ri62 N485 N124 60.0
Rs63 N127 N486 1e-05
V63 N486 N487 3.6
Ri63 N487 N126 60.0
Rs64 N129 N488 1e-05
V64 N488 N489 3.6
Ri64 N489 N128 60.0
Rs65 N131 N490 1e-05
V65 N490 N491 3.6
Ri65 N491 N130 60.0
Rs66 N133 N492 1e-05
V66 N492 N493 3.6
Ri66 N493 N132 60.0
Rs67 N135 N494 1e-05
V67 N494 N495 3.6
Ri67 N495 N134 60.0
Rs68 N137 N496 1e-05
V68 N496 N497 3.6
Ri68 N497 N136 60.0
Rs69 N139 N498 1e-05
V69 N498 N499 3.6
Ri69 N499 N138 60.0
Rs70 N141 N500 1e-05
V70 N500 N501 3.6
Ri70 N501 N140 60.0
Rs71 N143 N502 1e-05
V71 N502 N503 3.6
Ri71 N503 N142 60.0
Rs72 N145 N504 1e-05
V72 N504 N505 3.6
Ri72 N505 N144 60.0
Rs73 N147 N506 1e-05
V73 N506 N507 3.6
Ri73 N507 N146 60.0
Rs74 N149 N508 1e-05
V74 N508 N509 3.6
Ri74 N509 N148 60.0
Rs75 N151 N510 1e-05
V75 N510 N511 3.6
Ri75 N511 N150 60.0
Rs76 N153 N512 1e-05
V76 N512 N513 3.6
Ri76 N513 N152 60.0
Rs77 N155 N514 1e-05
V77 N514 N515 3.6
Ri77 N515 N154 60.0
Rs78 N157 N516 1e-05
V78 N516 N517 3.6
Ri78 N517 N156 60.0
Rs79 N159 N518 1e-05
V79 N518 N519 3.6
Ri79 N519 N158 60.0
Rs80 N161 N520 1e-05
V80 N520 N521 3.6
Ri80 N521 N160 60.0
Rs81 N163 N522 1e-05
V81 N522 N523 3.6
Ri81 N523 N162 60.0
Rs82 N165 N524 1e-05
V82 N524 N525 3.6
Ri82 N525 N164 60.0
Rs83 N167 N526 1e-05
V83 N526 N527 3.6
Ri83 N527 N166 60.0
Rs84 N169 N528 1e-05
V84 N528 N529 3.6
Ri84 N529 N168 60.0
Rs85 N171 N530 1e-05
V85 N530 N531 3.6
Ri85 N531 N170 60.0
Rs86 N173 N532 1e-05
V86 N532 N533 3.6
Ri86 N533 N172 60.0
Rs87 N175 N534 1e-05
V87 N534 N535 3.6
Ri87 N535 N174 60.0
Rs88 N177 N536 1e-05
V88 N536 N537 3.6
Ri88 N537 N176 60.0
Rs89 N179 N538 1e-05
V89 N538 N539 3.6
Ri89 N539 N178 60.0
Rs90 N181 N540 1e-05
V90 N540 N541 3.6
Ri90 N541 N180 60.0
Rs91 N183 N542 1e-05
V91 N542 N543 3.6
Ri91 N543 N182 60.0
Rs92 N185 N544 1e-05
V92 N544 N545 3.6
Ri92 N545 N184 60.0
Rs93 N187 N546 1e-05
V93 N546 N547 3.6
Ri93 N547 N186 60.0
Rs94 N189 N548 1e-05
V94 N548 N549 3.6
Ri94 N549 N188 60.0
Rs95 N191 N550 1e-05
V95 N550 N551 3.6
Ri95 N551 N190 60.0
Rs96 N193 N552 1e-05
V96 N552 N553 3.6
Ri96 N553 N192 60.0
Rs97 N195 N554 1e-05
V97 N554 N555 3.6
Ri97 N555 N194 60.0
Rs98 N197 N556 1e-05
V98 N556 N557 3.6
Ri98 N557 N196 60.0
Rs99 N199 N558 1e-05
V99 N558 N559 3.6
Ri99 N559 N198 60.0
Rs100 N201 N560 1e-05
V100 N560 N561 3.6
Ri100 N561 N200 60.0
Rs101 N203 N562 1e-05
V101 N562 N563 3.6
Ri101 N563 N202 60.0
Rs102 N205 N564 1e-05
V102 N564 N565 3.6
Ri102 N565 N204 60.0
Rs103 N207 N566 1e-05
V103 N566 N567 3.6
Ri103 N567 N206 60.0
Rs104 N209 N568 1e-05
V104 N568 N569 3.6
Ri104 N569 N208 60.0
Rs105 N211 N570 1e-05
V105 N570 N571 3.6
Ri105 N571 N210 60.0
Rs106 N213 N572 1e-05
V106 N572 N573 3.6
Ri106 N573 N212 60.0
Rs107 N215 N574 1e-05
V107 N574 N575 3.6
Ri107 N575 N214 60.0
Rs108 N217 N576 1e-05
V108 N576 N577 3.6
Ri108 N577 N216 60.0
Rs109 N219 N578 1e-05
V109 N578 N579 3.6
Ri109 N579 N218 60.0
Rs110 N221 N580 1e-05
V110 N580 N581 3.6
Ri110 N581 N220 60.0
Rs111 N223 N582 1e-05
V111 N582 N583 3.6
Ri111 N583 N222 60.0
Rs112 N225 N584 1e-05
V112 N584 N585 3.6
Ri112 N585 N224 60.0
Rs113 N227 N586 1e-05
V113 N586 N587 3.6
Ri113 N587 N226 60.0
Rs114 N229 N588 1e-05
V114 N588 N589 3.6
Ri114 N589 N228 60.0
Rs115 N231 N590 1e-05
V115 N590 N591 3.6
Ri115 N591 N230 60.0
Rs116 N233 N592 1e-05
V116 N592 N593 3.6
Ri116 N593 N232 60.0
Rs117 N235 N594 1e-05
V117 N594 N595 3.6
Ri117 N595 N234 60.0
Rs118 N237 N596 1e-05
V118 N596 N597 3.6
Ri118 N597 N236 60.0
Rs119 N239 N598 1e-05
V119 N598 N599 3.6
Ri119 N599 N238 60.0
Rs120 N241 N600 1e-05
V120 N600 N601 3.6
Ri120 N601 N240 60.0
Rs121 N243 N602 1e-05
V121 N602 N603 3.6
Ri121 N603 N242 60.0
Rs122 N245 N604 1e-05
V122 N604 N605 3.6
Ri122 N605 N244 60.0
Rs123 N247 N606 1e-05
V123 N606 N607 3.6
Ri123 N607 N246 60.0
Rs124 N249 N608 1e-05
V124 N608 N609 3.6
Ri124 N609 N248 60.0
Rs125 N251 N610 1e-05
V125 N610 N611 3.6
Ri125 N611 N250 60.0
Rs126 N253 N612 1e-05
V126 N612 N613 3.6
Ri126 N613 N252 60.0
Rs127 N255 N614 1e-05
V127 N614 N615 3.6
Ri127 N615 N254 60.0
Rs128 N257 N616 1e-05
V128 N616 N617 3.6
Ri128 N617 N256 60.0
Rs129 N259 N618 1e-05
V129 N618 N619 3.6
Ri129 N619 N258 60.0
Rs130 N261 N620 1e-05
V130 N620 N621 3.6
Ri130 N621 N260 60.0
Rs131 N263 N622 1e-05
V131 N622 N623 3.6
Ri131 N623 N262 60.0
Rs132 N265 N624 1e-05
V132 N624 N625 3.6
Ri132 N625 N264 60.0
Rs133 N267 N626 1e-05
V133 N626 N627 3.6
Ri133 N627 N266 60.0
Rs134 N269 N628 1e-05
V134 N628 N629 3.6
Ri134 N629 N268 60.0
Rs135 N271 N630 1e-05
V135 N630 N631 3.6
Ri135 N631 N270 60.0
Rs136 N273 N632 1e-05
V136 N632 N633 3.6
Ri136 N633 N272 60.0
Rs137 N275 N634 1e-05
V137 N634 N635 3.6
Ri137 N635 N274 60.0
Rs138 N277 N636 1e-05
V138 N636 N637 3.6
Ri138 N637 N276 60.0
Rs139 N279 N638 1e-05
V139 N638 N639 3.6
Ri139 N639 N278 60.0
Rs140 N281 N640 1e-05
V140 N640 N641 3.6
Ri140 N641 N280 60.0
Rs141 N283 N642 1e-05
V141 N642 N643 3.6
Ri141 N643 N282 60.0
Rs142 N285 N644 1e-05
V142 N644 N645 3.6
Ri142 N645 N284 60.0
Rs143 N287 N646 1e-05
V143 N646 N647 3.6
Ri143 N647 N286 60.0
Rs144 N289 N648 1e-05
V144 N648 N649 3.6
Ri144 N649 N288 60.0
Rs145 N291 N650 1e-05
V145 N650 N651 3.6
Ri145 N651 N290 60.0
Rs146 N293 N652 1e-05
V146 N652 N653 3.6
Ri146 N653 N292 60.0
Rs147 N295 N654 1e-05
V147 N654 N655 3.6
Ri147 N655 N294 60.0
Rs148 N297 N656 1e-05
V148 N656 N657 3.6
Ri148 N657 N296 60.0
Rs149 N299 N658 1e-05
V149 N658 N659 3.6
Ri149 N659 N298 60.0
Rs150 N301 N660 1e-05
V150 N660 N661 3.6
Ri150 N661 N300 60.0
Rs151 N303 N662 1e-05
V151 N662 N663 3.6
Ri151 N663 N302 60.0
Rs152 N305 N664 1e-05
V152 N664 N665 3.6
Ri152 N665 N304 60.0
Rs153 N307 N666 1e-05
V153 N666 N667 3.6
Ri153 N667 N306 60.0
Rs154 N309 N668 1e-05
V154 N668 N669 3.6
Ri154 N669 N308 60.0
Rs155 N311 N670 1e-05
V155 N670 N671 3.6
Ri155 N671 N310 60.0
Rs156 N313 N672 1e-05
V156 N672 N673 3.6
Ri156 N673 N312 60.0
Rs157 N315 N674 1e-05
V157 N674 N675 3.6
Ri157 N675 N314 60.0
Rs158 N317 N676 1e-05
V158 N676 N677 3.6
Ri158 N677 N316 60.0
Rs159 N319 N678 1e-05
V159 N678 N679 3.6
Ri159 N679 N318 60.0
Rs160 N321 N680 1e-05
V160 N680 N681 3.6
Ri160 N681 N320 60.0
Rs161 N323 N682 1e-05
V161 N682 N683 3.6
Ri161 N683 N322 60.0
Rs162 N325 N684 1e-05
V162 N684 N685 3.6
Ri162 N685 N324 60.0
Rs163 N327 N686 1e-05
V163 N686 N687 3.6
Ri163 N687 N326 60.0
Rs164 N329 N688 1e-05
V164 N688 N689 3.6
Ri164 N689 N328 60.0
Rs165 N331 N690 1e-05
V165 N690 N691 3.6
Ri165 N691 N330 60.0
Rs166 N333 N692 1e-05
V166 N692 N693 3.6
Ri166 N693 N332 60.0
Rs167 N335 N694 1e-05
V167 N694 N695 3.6
Ri167 N695 N334 60.0
Rs168 N337 N696 1e-05
V168 N696 N697 3.6
Ri168 N697 N336 60.0
Rs169 N339 N698 1e-05
V169 N698 N699 3.6
Ri169 N699 N338 60.0
Rs170 N341 N700 1e-05
V170 N700 N701 3.6
Ri170 N701 N340 60.0
Rs171 N343 N702 1e-05
V171 N702 N703 3.6
Ri171 N703 N342 60.0
Rs172 N345 N704 1e-05
V172 N704 N705 3.6
Ri172 N705 N344 60.0
Rs173 N347 N706 1e-05
V173 N706 N707 3.6
Ri173 N707 N346 60.0
Rs174 N349 N708 1e-05
V174 N708 N709 3.6
Ri174 N709 N348 60.0
Rs175 N351 N710 1e-05
V175 N710 N711 3.6
Ri175 N711 N350 60.0
Rs176 N353 N712 1e-05
V176 N712 N713 3.6
Ri176 N713 N352 60.0
Rs177 N355 N714 1e-05
V177 N714 N715 3.6
Ri177 N715 N354 60.0
Rs178 N357 N716 1e-05
V178 N716 N717 3.6
Ri178 N717 N356 60.0
Rs179 N359 N718 1e-05
V179 N718 N719 3.6
Ri179 N719 N358 60.0
Rs538 N001 N720 1e-05
V538 N720 N721 3.6
Ri538 N721 N072 60.0
Rs539 N003 N722 1e-05
V539 N722 N723 3.6
Ri539 N723 N074 60.0
Rs540 N005 N724 1e-05
V540 N724 N725 3.6
Ri540 N725 N076 60.0
Rs541 N007 N726 1e-05
V541 N726 N727 3.6
Ri541 N727 N078 60.0
Rs542 N009 N728 1e-05
V542 N728 N729 3.6
Ri542 N729 N080 60.0
Rs543 N011 N730 1e-05
V543 N730 N731 3.6
Ri543 N731 N082 60.0
Rs544 N013 N732 1e-05
V544 N732 N733 3.6
Ri544 N733 N084 60.0
Rs545 N015 N734 1e-05
V545 N734 N735 3.6
Ri545 N735 N086 60.0
Rs546 N017 N736 1e-05
V546 N736 N737 3.6
Ri546 N737 N088 60.0
Rs547 N019 N738 1e-05
V547 N738 N739 3.6
Ri547 N739 N090 60.0
Rs548 N021 N740 1e-05
V548 N740 N741 3.6
Ri548 N741 N092 60.0
Rs549 N023 N742 1e-05
V549 N742 N743 3.6
Ri549 N743 N094 60.0
Rs550 N025 N744 1e-05
V550 N744 N745 3.6
Ri550 N745 N096 60.0
Rs551 N027 N746 1e-05
V551 N746 N747 3.6
Ri551 N747 N098 60.0
Rs552 N029 N748 1e-05
V552 N748 N749 3.6
Ri552 N749 N100 60.0
Rs553 N031 N750 1e-05
V553 N750 N751 3.6
Ri553 N751 N102 60.0
Rs554 N033 N752 1e-05
V554 N752 N753 3.6
Ri554 N753 N104 60.0
Rs555 N035 N754 1e-05
V555 N754 N755 3.6
Ri555 N755 N106 60.0
Rs556 N037 N756 1e-05
V556 N756 N757 3.6
Ri556 N757 N108 60.0
Rs557 N039 N758 1e-05
V557 N758 N759 3.6
Ri557 N759 N110 60.0
Rs558 N041 N760 1e-05
V558 N760 N761 3.6
Ri558 N761 N112 60.0
Rs559 N043 N762 1e-05
V559 N762 N763 3.6
Ri559 N763 N114 60.0
Rs560 N045 N764 1e-05
V560 N764 N765 3.6
Ri560 N765 N116 60.0
Rs561 N047 N766 1e-05
V561 N766 N767 3.6
Ri561 N767 N118 60.0
Rs562 N049 N768 1e-05
V562 N768 N769 3.6
Ri562 N769 N120 60.0
Rs563 N051 N770 1e-05
V563 N770 N771 3.6
Ri563 N771 N122 60.0
Rs564 N053 N772 1e-05
V564 N772 N773 3.6
Ri564 N773 N124 60.0
Rs565 N055 N774 1e-05
V565 N774 N775 3.6
Ri565 N775 N126 60.0
Rs566 N057 N776 1e-05
V566 N776 N777 3.6
Ri566 N777 N128 60.0
Rs567 N059 N778 1e-05
V567 N778 N779 3.6
Ri567 N779 N130 60.0
Rs568 N061 N780 1e-05
V568 N780 N781 3.6
Ri568 N781 N132 60.0
Rs569 N063 N782 1e-05
V569 N782 N783 3.6
Ri569 N783 N134 60.0
Rs570 N065 N784 1e-05
V570 N784 N785 3.6
Ri570 N785 N136 60.0
Rs571 N067 N786 1e-05
V571 N786 N787 3.6
Ri571 N787 N138 60.0
Rs572 N069 N788 1e-05
V572 N788 N789 3.6
Ri572 N789 N140 60.0
Rs573 N071 N790 1e-05
V573 N790 N791 3.6
Ri573 N791 N142 60.0
Rs574 N073 N792 1e-05
V574 N792 N793 3.6
Ri574 N793 N144 60.0
Rs575 N075 N794 1e-05
V575 N794 N795 3.6
Ri575 N795 N146 60.0
Rs576 N077 N796 1e-05
V576 N796 N797 3.6
Ri576 N797 N148 60.0
Rs577 N079 N798 1e-05
V577 N798 N799 3.6
Ri577 N799 N150 60.0
Rs578 N081 N800 1e-05
V578 N800 N801 3.6
Ri578 N801 N152 60.0
Rs579 N083 N802 1e-05
V579 N802 N803 3.6
Ri579 N803 N154 60.0
Rs580 N085 N804 1e-05
V580 N804 N805 3.6
Ri580 N805 N156 60.0
Rs581 N087 N806 1e-05
V581 N806 N807 3.6
Ri581 N807 N158 60.0
Rs582 N089 N808 1e-05
V582 N808 N809 3.6
Ri582 N809 N160 60.0
Rs583 N091 N810 1e-05
V583 N810 N811 3.6
Ri583 N811 N162 60.0
Rs584 N093 N812 1e-05
V584 N812 N813 3.6
Ri584 N813 N164 60.0
Rs585 N095 N814 1e-05
V585 N814 N815 3.6
Ri585 N815 N166 60.0
Rs586 N097 N816 1e-05
V586 N816 N817 3.6
Ri586 N817 N168 60.0
Rs587 N099 N818 1e-05
V587 N818 N819 3.6
Ri587 N819 N170 60.0
Rs588 N101 N820 1e-05
V588 N820 N821 3.6
Ri588 N821 N172 60.0
Rs589 N103 N822 1e-05
V589 N822 N823 3.6
Ri589 N823 N174 60.0
Rs590 N105 N824 1e-05
V590 N824 N825 3.6
Ri590 N825 N176 60.0
Rs591 N107 N826 1e-05
V591 N826 N827 3.6
Ri591 N827 N178 60.0
Rs592 N109 N828 1e-05
V592 N828 N829 3.6
Ri592 N829 N180 60.0
Rs593 N111 N830 1e-05
V593 N830 N831 3.6
Ri593 N831 N182 60.0
Rs594 N113 N832 1e-05
V594 N832 N833 3.6
Ri594 N833 N184 60.0
Rs595 N115 N834 1e-05
V595 N834 N835 3.6
Ri595 N835 N186 60.0
Rs596 N117 N836 1e-05
V596 N836 N837 3.6
Ri596 N837 N188 60.0
Rs597 N119 N838 1e-05
V597 N838 N839 3.6
Ri597 N839 N190 60.0
Rs598 N121 N840 1e-05
V598 N840 N841 3.6
Ri598 N841 N192 60.0
Rs599 N123 N842 1e-05
V599 N842 N843 3.6
Ri599 N843 N194 60.0
Rs600 N125 N844 1e-05
V600 N844 N845 3.6
Ri600 N845 N196 60.0
Rs601 N127 N846 1e-05
V601 N846 N847 3.6
Ri601 N847 N198 60.0
Rs602 N129 N848 1e-05
V602 N848 N849 3.6
Ri602 N849 N200 60.0
Rs603 N131 N850 1e-05
V603 N850 N851 3.6
Ri603 N851 N202 60.0
Rs604 N133 N852 1e-05
V604 N852 N853 3.6
Ri604 N853 N204 60.0
Rs605 N135 N854 1e-05
V605 N854 N855 3.6
Ri605 N855 N206 60.0
Rs606 N137 N856 1e-05
V606 N856 N857 3.6
Ri606 N857 N208 60.0
Rs607 N139 N858 1e-05
V607 N858 N859 3.6
Ri607 N859 N210 60.0
Rs608 N141 N860 1e-05
V608 N860 N861 3.6
Ri608 N861 N212 60.0
Rs609 N143 N862 1e-05
V609 N862 N863 3.6
Ri609 N863 N214 60.0
Rs610 N145 N864 1e-05
V610 N864 N865 3.6
Ri610 N865 N216 60.0
Rs611 N147 N866 1e-05
V611 N866 N867 3.6
Ri611 N867 N218 60.0
Rs612 N149 N868 1e-05
V612 N868 N869 3.6
Ri612 N869 N220 60.0
Rs613 N151 N870 1e-05
V613 N870 N871 3.6
Ri613 N871 N222 60.0
Rs614 N153 N872 1e-05
V614 N872 N873 3.6
Ri614 N873 N224 60.0
Rs615 N155 N874 1e-05
V615 N874 N875 3.6
Ri615 N875 N226 60.0
Rs616 N157 N876 1e-05
V616 N876 N877 3.6
Ri616 N877 N228 60.0
Rs617 N159 N878 1e-05
V617 N878 N879 3.6
Ri617 N879 N230 60.0
Rs618 N161 N880 1e-05
V618 N880 N881 3.6
Ri618 N881 N232 60.0
Rs619 N163 N882 1e-05
V619 N882 N883 3.6
Ri619 N883 N234 60.0
Rs620 N165 N884 1e-05
V620 N884 N885 3.6
Ri620 N885 N236 60.0
Rs621 N167 N886 1e-05
V621 N886 N887 3.6
Ri621 N887 N238 60.0
Rs622 N169 N888 1e-05
V622 N888 N889 3.6
Ri622 N889 N240 60.0
Rs623 N171 N890 1e-05
V623 N890 N891 3.6
Ri623 N891 N242 60.0
Rs624 N173 N892 1e-05
V624 N892 N893 3.6
Ri624 N893 N244 60.0
Rs625 N175 N894 1e-05
V625 N894 N895 3.6
Ri625 N895 N246 60.0
Rs626 N177 N896 1e-05
V626 N896 N897 3.6
Ri626 N897 N248 60.0
Rs627 N179 N898 1e-05
V627 N898 N899 3.6
Ri627 N899 N250 60.0
Rs628 N181 N900 1e-05
V628 N900 N901 3.6
Ri628 N901 N252 60.0
Rs629 N183 N902 1e-05
V629 N902 N903 3.6
Ri629 N903 N254 60.0
Rs630 N185 N904 1e-05
V630 N904 N905 3.6
Ri630 N905 N256 60.0
Rs631 N187 N906 1e-05
V631 N906 N907 3.6
Ri631 N907 N258 60.0
Rs632 N189 N908 1e-05
V632 N908 N909 3.6
Ri632 N909 N260 60.0
Rs633 N191 N910 1e-05
V633 N910 N911 3.6
Ri633 N911 N262 60.0
Rs634 N193 N912 1e-05
V634 N912 N913 3.6
Ri634 N913 N264 60.0
Rs635 N195 N914 1e-05
V635 N914 N915 3.6
Ri635 N915 N266 60.0
Rs636 N197 N916 1e-05
V636 N916 N917 3.6
Ri636 N917 N268 60.0
Rs637 N199 N918 1e-05
V637 N918 N919 3.6
Ri637 N919 N270 60.0
Rs638 N201 N920 1e-05
V638 N920 N921 3.6
Ri638 N921 N272 60.0
Rs639 N203 N922 1e-05
V639 N922 N923 3.6
Ri639 N923 N274 60.0
Rs640 N205 N924 1e-05
V640 N924 N925 3.6
Ri640 N925 N276 60.0
Rs641 N207 N926 1e-05
V641 N926 N927 3.6
Ri641 N927 N278 60.0
Rs642 N209 N928 1e-05
V642 N928 N929 3.6
Ri642 N929 N280 60.0
Rs643 N211 N930 1e-05
V643 N930 N931 3.6
Ri643 N931 N282 60.0
Rs644 N213 N932 1e-05
V644 N932 N933 3.6
Ri644 N933 N284 60.0
Rs645 N215 N934 1e-05
V645 N934 N935 3.6
Ri645 N935 N286 60.0
Rs646 N217 N936 1e-05
V646 N936 N937 3.6
Ri646 N937 N288 60.0
Rs647 N219 N938 1e-05
V647 N938 N939 3.6
Ri647 N939 N290 60.0
Rs648 N221 N940 1e-05
V648 N940 N941 3.6
Ri648 N941 N292 60.0
Rs649 N223 N942 1e-05
V649 N942 N943 3.6
Ri649 N943 N294 60.0
Rs650 N225 N944 1e-05
V650 N944 N945 3.6
Ri650 N945 N296 60.0
Rs651 N227 N946 1e-05
V651 N946 N947 3.6
Ri651 N947 N298 60.0
Rs652 N229 N948 1e-05
V652 N948 N949 3.6
Ri652 N949 N300 60.0
Rs653 N231 N950 1e-05
V653 N950 N951 3.6
Ri653 N951 N302 60.0
Rs654 N233 N952 1e-05
V654 N952 N953 3.6
Ri654 N953 N304 60.0
Rs655 N235 N954 1e-05
V655 N954 N955 3.6
Ri655 N955 N306 60.0
Rs656 N237 N956 1e-05
V656 N956 N957 3.6
Ri656 N957 N308 60.0
Rs657 N239 N958 1e-05
V657 N958 N959 3.6
Ri657 N959 N310 60.0
Rs658 N241 N960 1e-05
V658 N960 N961 3.6
Ri658 N961 N312 60.0
Rs659 N243 N962 1e-05
V659 N962 N963 3.6
Ri659 N963 N314 60.0
Rs660 N245 N964 1e-05
V660 N964 N965 3.6
Ri660 N965 N316 60.0
Rs661 N247 N966 1e-05
V661 N966 N967 3.6
Ri661 N967 N318 60.0
Rs662 N249 N968 1e-05
V662 N968 N969 3.6
Ri662 N969 N320 60.0
Rs663 N251 N970 1e-05
V663 N970 N971 3.6
Ri663 N971 N322 60.0
Rs664 N253 N972 1e-05
V664 N972 N973 3.6
Ri664 N973 N324 60.0
Rs665 N255 N974 1e-05
V665 N974 N975 3.6
Ri665 N975 N326 60.0
Rs666 N257 N976 1e-05
V666 N976 N977 3.6
Ri666 N977 N328 60.0
Rs667 N259 N978 1e-05
V667 N978 N979 3.6
Ri667 N979 N330 60.0
Rs668 N261 N980 1e-05
V668 N980 N981 3.6
Ri668 N981 N332 60.0
Rs669 N263 N982 1e-05
V669 N982 N983 3.6
Ri669 N983 N334 60.0
Rs670 N265 N984 1e-05
V670 N984 N985 3.6
Ri670 N985 N336 60.0
Rs671 N267 N986 1e-05
V671 N986 N987 3.6
Ri671 N987 N338 60.0
Rs672 N269 N988 1e-05
V672 N988 N989 3.6
Ri672 N989 N340 60.0
Rs673 N271 N990 1e-05
V673 N990 N991 3.6
Ri673 N991 N342 60.0
Rs674 N273 N992 1e-05
V674 N992 N993 3.6
Ri674 N993 N344 60.0
Rs675 N275 N994 1e-05
V675 N994 N995 3.6
Ri675 N995 N346 60.0
Rs676 N277 N996 1e-05
V676 N996 N997 3.6
Ri676 N997 N348 60.0
Rs677 N279 N998 1e-05
V677 N998 N999 3.6
Ri677 N999 N350 60.0
Rs678 N281 N1000 1e-05
V678 N1000 N1001 3.6
Ri678 N1001 N352 60.0
Rs679 N283 N1002 1e-05
V679 N1002 N1003 3.6
Ri679 N1003 N354 60.0
Rs680 N285 N1004 1e-05
V680 N1004 N1005 3.6
Ri680 N1005 N356 60.0
Rs681 N287 N1006 1e-05
V681 N1006 N1007 3.6
Ri681 N1007 N358 60.0
I0 N359 0 -5.0
.op
.backanno
.end
